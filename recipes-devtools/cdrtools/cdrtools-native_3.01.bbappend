FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://install-sh-roottest.patch"
