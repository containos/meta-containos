# http://git.openembedded.org/openembedded-core/commit/meta/recipes-devtools/intltool/intltool_0.51.0.bb?id=26bd53aebf3430f1b9ec459c6c6ab42c57d18319
DEPENDS_append_class-native = " gettext-native"
