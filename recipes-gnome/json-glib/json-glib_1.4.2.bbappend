# bugfix: gettext cannot be disabled in meson
USE_NLS = "yes"
